# Keil uVision project STM32F103C8T6.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8T6
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\lib\inc;..\system;..\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../lib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group user
    ./: main.c
  group start
    ../start/: startup_stm32f10x_md.s
  group system
    ../system/: delay.c PID.c SysInit.C CAN1.c Control.C AI.c USART1.c
